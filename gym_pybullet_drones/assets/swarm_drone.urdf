Commit message: Mass 900g

File: gym_pybullet_drones/assets/swarm_drone.urdf (robot description, URDF)
Before this commit: robot swarm_drone, 6 links, 5 joints
Links:
- link base_link: mass 0.027 -> 0.9
